# MHz S RI R 100.0
!  S11  S12  S21  S22
!MHz  Real  Imag  Real  Imag  Real  Imag  Real  Imag
! Worked out from all points (low-pass shape):
!   1023 points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, 9.766 MHz to 9.99 GHz, reference 100 ohm
!   highest |S21| = -0.19 dB at 9.766 MHz (marker M1); lowest = -51.6 dB at 9.99 GHz (marker M2)
!   |S21| within 3 dB of the highest: start of sweep to 807.3 MHz
!   lowest |S11| = - dB at 9.766 MHz (marker M3), VSWR 1.00, Z = 100 + j0 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from - to - dB; largest |S21 - S12| = 0
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! magnitudes (dB):
! f  S21  S12
! 9.766 MHz  -0.2  -0.2
! 156.2 MHz  -1.0  -1.0
! 351.6 MHz  -1.7  -1.7
! 1.68 GHz  -6.0  -6.0
! 2.529 GHz  -9.1  -9.1
! 3.34 GHz  -12.3  -12.3
! 3.76 GHz  -14.0  -14.0
! 4.17 GHz  -15.9  -15.9
! 4.59 GHz  -17.8  -17.8
! 5 GHz  -19.8  -19.8
! 5.42 GHz  -22.0  -22.0
! 5.84 GHz  -24.2  -24.2
! 6.26 GHz  -26.6  -26.6
! 6.67 GHz  -28.9  -28.9
! 7.09 GHz  -31.5  -31.5
! 7.5 GHz  -34.0  -34.0
! 7.92 GHz  -36.8  -36.8
! 8.33 GHz  -39.5  -39.5
! 9.053 GHz  -44.6  -44.6
! 9.502 GHz  -47.9  -47.9
! 9.941 GHz  -51.2  -51.2
! 9.99 GHz  -51.6  -51.6
